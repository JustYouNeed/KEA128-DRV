# Keil uVision project DRV.uvprojx, settings and files
target DRV (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: SKEAZ128xxx4 NXP
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\USER;..\CORE;..\BSP\inc;..\DRV\inc;..\APP\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group USER
    ./: main.c
  group CORE
    ../CORE/: startup_SKEAZ1284.s system_SKEAZ1284.c
  group DRV
    ../DRV/src/: drv_gpio.c drv_pit.c drv_uart.c drv_rcc.c drv_adc.c drv_ftm.c drv_spi.c drv_wdog.c drv_acmp.c drv_flash.c drv_irq.c drv_power.c drv_pwt.c drv_rtc.c drv_kbi.c
  group BSP
    ../BSP/src/: bsp.c bsp_led.c bsp_uart.c bsp_timer.c bsp_key.c bsp_oled.c bsp_flash.c
